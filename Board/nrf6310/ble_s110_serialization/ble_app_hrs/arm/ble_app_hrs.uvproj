# Keil uVision project ble_app_hrs.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310,SVCALL_AS_NORMAL_FUNCTION, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\ble\rpc;..\..\..\..\..\Include\sd_common
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group Startup Code
    ../../../../../Source/templates/: system_nrf51.c
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
  group Source Code
    ../: main.c
    ../../platform/nrf51_blank/: pstorage.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_hrs.c ble_dis.c ble_bas.c
  group Libraries
    ../../../../../Source/ble/: ble_bondmngr.c ble_conn_params.c ble_debug_assert_handler.c ble_sensorsim.c ble_advdata.c ble_error_log.c ble_flash.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/app_common/: app_timer.c app_gpiote.c app_scheduler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
  group ble_rpc_codecs
    ../../../../../Source/ble/rpc/: ble_rpc_sd_stub.c ble_rpc_pkt_receiver.c ble_rpc_cmd_encoder.c ble_rpc_cmd_encoder_gap.c ble_rpc_cmd_encoder_gatts.c ble_rpc_event_decoder.c ble_rpc_event_decoder_gap.c ble_rpc_event_decoder_gatts.c
  group hci_transport
    ../../../../../Source/app_common/: hci_transport.c hci_slip.c hci_mem_pool.c app_uart.c crc16.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_hrs +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
