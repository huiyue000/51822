# Keil uVision project ble_app_advertising.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_advertising +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310,SVCALL_AS_NORMAL_FUNCTION,BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\rpc;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x00000000 size 0x00040000
  memory RVCT9: RAM 0x20000000 size 0x00004000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../../../../../Source/ble/: ble_advdata.c ble_debug_assert_handler.c ble_flash.c ble_error_log.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/app_common/: app_uart.c app_gpiote.c app_scheduler.c hci_mem_pool.c hci_slip.c hci_transport.c app_timer.c crc16.c
    ../../../../../Source/ble/rpc/: ble_rpc_cmd_encoder.c ble_rpc_event_decoder.c ble_rpc_sd_stub.c ble_rpc_cmd_encoder_gap.c ble_rpc_cmd_encoder_gatts.c ble_rpc_event_decoder_gap.c ble_rpc_event_decoder_gatts.c ble_rpc_pkt_receiver.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_advertising +hex
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x00000000 size 0x00020000
  memory RVCT9: RAM 0x20000000 size 0x00004000
